<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_loopback</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>GDTP</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>GDTP</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>max_pdu_size</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>Max PDU size</value></param>
<param><key>max</key><value>1500</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>msg_interval</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>label</key><value>Message Interval [ms]</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>text_msg</value></param>
<param><key>value</key><value>"This is a test message"</value></param>
</block>
<block>
<key>gdtp_gdtp_wrapper</key>
<param><key>id</key><value>a</value></param>
<param><key>ack_timeout</key><value>100</value></param>
<param><key>addr_source</key><value>tun0</value></param>
<param><key>addr_mode</key><value>Explicit</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dest_addr</key><value>1</value></param>
<param><key>num_flows</key><value>2</value></param>
<param><key>max_retry</key><value>7</value></param>
<param><key>max_seq_no</key><value>127</value></param>
<param><key>reliable</key><value>[1,0]</value></param>
<param><key>scheduler</key><value>fifo</value></param>
<param><key>src_addr</key><value>2</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern(text_msg)</value></param>
<param><key>period</key><value>msg_interval</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern(text_msg)</value></param>
<param><key>period</key><value>msg_interval</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>max_pdu_size</value></param>
<param><key>minsize</key><value>1</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>max_pdu_size</value></param>
<param><key>minsize</key><value>1</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tun0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>gdtp_gdtp_wrapper</key>
<param><key>id</key><value>gdtp_gdtp_wrapper_0</value></param>
<param><key>ack_timeout</key><value>100</value></param>
<param><key>addr_source</key><value>tun0</value></param>
<param><key>addr_mode</key><value>Explicit</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dest_addr</key><value>2</value></param>
<param><key>num_flows</key><value>2</value></param>
<param><key>max_retry</key><value>7</value></param>
<param><key>max_seq_no</key><value>127</value></param>
<param><key>reliable</key><value>[1,0]</value></param>
<param><key>scheduler</key><value>fifo</value></param>
<param><key>src_addr</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>you can connect to the Socket PDU with: 'nc -u localhost 52002'</value></param>
</block>
<connection><source_block_id>a</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>flowout0</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>a</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>flowout1</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>a</source_block_id><sink_block_id>gdtp_gdtp_wrapper_0</sink_block_id><source_key>toMAC</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>blocks_random_pdu_0_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>gdtp_gdtp_wrapper_0</sink_block_id><source_key>pdus</source_key><sink_key>flowin0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0_0</source_block_id><sink_block_id>gdtp_gdtp_wrapper_0</sink_block_id><source_key>pdus</source_key><sink_key>flowin1</sink_key></connection>
<connection><source_block_id>gdtp_gdtp_wrapper_0</source_block_id><sink_block_id>a</sink_block_id><source_key>toMAC</source_key><sink_key>fromMAC</sink_key></connection>
</flow_graph>
